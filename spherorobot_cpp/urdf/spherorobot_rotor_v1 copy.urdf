Commit message: add all calculations

File: spherorobot_cpp/urdf/spherorobot_rotor_v1 copy.urdf (robot description, URDF)
Before this commit: robot spherorobot_rotor_v1, 4 links, 3 joints
Links:
- link sphere_link: mass 0.072 -> 0.08
